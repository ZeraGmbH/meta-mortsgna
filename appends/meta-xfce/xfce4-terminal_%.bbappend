RRECOMMENDS_${PN} += "xfce4-terminal-default-config"
